## Kconfig
```kconfig
config ELM327
	tristate "Serial ELM327 driver"
	depends on USB
	help
	  Help message of ELM327
```
